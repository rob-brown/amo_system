#include "protocol/aes128.h"

#include <stddef.h>
#include <string.h>

#define ROUND_COUNT 10
#define STATE_SIZE 16
#define EXPANDED_KEY_SIZE (STATE_SIZE * (ROUND_COUNT + 1))
#define COLUMN_COUNT 4
#define ROW_COUNT 4
#define REDUCTION_POLYNOMIAL 0x1B

static const uint8_t SUBSTITUTION_BOX[256] = {
    0x63, 0x7C, 0x77, 0x7B, 0xF2, 0x6B, 0x6F, 0xC5, 0x30, 0x01, 0x67, 0x2B, 0xFE, 0xD7, 0xAB, 0x76,
    0xCA, 0x82, 0xC9, 0x7D, 0xFA, 0x59, 0x47, 0xF0, 0xAD, 0xD4, 0xA2, 0xAF, 0x9C, 0xA4, 0x72, 0xC0,
    0xB7, 0xFD, 0x93, 0x26, 0x36, 0x3F, 0xF7, 0xCC, 0x34, 0xA5, 0xE5, 0xF1, 0x71, 0xD8, 0x31, 0x15,
    0x04, 0xC7, 0x23, 0xC3, 0x18, 0x96, 0x05, 0x9A, 0x07, 0x12, 0x80, 0xE2, 0xEB, 0x27, 0xB2, 0x75,
    0x09, 0x83, 0x2C, 0x1A, 0x1B, 0x6E, 0x5A, 0xA0, 0x52, 0x3B, 0xD6, 0xB3, 0x29, 0xE3, 0x2F, 0x84,
    0x53, 0xD1, 0x00, 0xED, 0x20, 0xFC, 0xB1, 0x5B, 0x6A, 0xCB, 0xBE, 0x39, 0x4A, 0x4C, 0x58, 0xCF,
    0xD0, 0xEF, 0xAA, 0xFB, 0x43, 0x4D, 0x33, 0x85, 0x45, 0xF9, 0x02, 0x7F, 0x50, 0x3C, 0x9F, 0xA8,
    0x51, 0xA3, 0x40, 0x8F, 0x92, 0x9D, 0x38, 0xF5, 0xBC, 0xB6, 0xDA, 0x21, 0x10, 0xFF, 0xF3, 0xD2,
    0xCD, 0x0C, 0x13, 0xEC, 0x5F, 0x97, 0x44, 0x17, 0xC4, 0xA7, 0x7E, 0x3D, 0x64, 0x5D, 0x19, 0x73,
    0x60, 0x81, 0x4F, 0xDC, 0x22, 0x2A, 0x90, 0x88, 0x46, 0xEE, 0xB8, 0x14, 0xDE, 0x5E, 0x0B, 0xDB,
    0xE0, 0x32, 0x3A, 0x0A, 0x49, 0x06, 0x24, 0x5C, 0xC2, 0xD3, 0xAC, 0x62, 0x91, 0x95, 0xE4, 0x79,
    0xE7, 0xC8, 0x37, 0x6D, 0x8D, 0xD5, 0x4E, 0xA9, 0x6C, 0x56, 0xF4, 0xEA, 0x65, 0x7A, 0xAE, 0x08,
    0xBA, 0x78, 0x25, 0x2E, 0x1C, 0xA6, 0xB4, 0xC6, 0xE8, 0xDD, 0x74, 0x1F, 0x4B, 0xBD, 0x8B, 0x8A,
    0x70, 0x3E, 0xB5, 0x66, 0x48, 0x03, 0xF6, 0x0E, 0x61, 0x35, 0x57, 0xB9, 0x86, 0xC1, 0x1D, 0x9E,
    0xE1, 0xF8, 0x98, 0x11, 0x69, 0xD9, 0x8E, 0x94, 0x9B, 0x1E, 0x87, 0xE9, 0xCE, 0x55, 0x28, 0xDF,
    0x8C, 0xA1, 0x89, 0x0D, 0xBF, 0xE6, 0x42, 0x68, 0x41, 0x99, 0x2D, 0x0F, 0xB0, 0x54, 0xBB, 0x16,
};

static const uint8_t ROUND_CONSTANTS[ROUND_COUNT] = {
    0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1B, 0x36,
};

static uint8_t multiply_by_two(uint8_t value) {
    uint8_t shifted = (uint8_t)(value << 1);
    return (value & 0x80) ? (uint8_t)(shifted ^ REDUCTION_POLYNOMIAL) : shifted;
}

static void expand_key(const uint8_t *key, uint8_t *expanded_key) {
    memcpy(expanded_key, key, AES128_KEY_SIZE);

    uint8_t constant_index = 0;
    for (size_t offset = AES128_KEY_SIZE; offset < EXPANDED_KEY_SIZE; offset += 4) {
        uint8_t word[4];
        memcpy(word, &expanded_key[offset - 4], sizeof(word));

        if (offset % AES128_KEY_SIZE == 0) {
            uint8_t first = word[0];
            word[0] = (uint8_t)(SUBSTITUTION_BOX[word[1]] ^ ROUND_CONSTANTS[constant_index++]);
            word[1] = SUBSTITUTION_BOX[word[2]];
            word[2] = SUBSTITUTION_BOX[word[3]];
            word[3] = SUBSTITUTION_BOX[first];
        }

        for (size_t index = 0; index < sizeof(word); index++) {
            expanded_key[offset + index] = expanded_key[offset - AES128_KEY_SIZE + index] ^ word[index];
        }
    }
}

static void add_round_key(uint8_t *state, const uint8_t *round_key) {
    for (size_t index = 0; index < STATE_SIZE; index++) {
        state[index] ^= round_key[index];
    }
}

static void substitute_bytes(uint8_t *state) {
    for (size_t index = 0; index < STATE_SIZE; index++) {
        state[index] = SUBSTITUTION_BOX[state[index]];
    }
}

static void shift_rows(uint8_t *state) {
    uint8_t original[STATE_SIZE];
    memcpy(original, state, STATE_SIZE);

    for (size_t column = 0; column < COLUMN_COUNT; column++) {
        for (size_t row = 0; row < ROW_COUNT; row++) {
            state[column * ROW_COUNT + row] = original[((column + row) % COLUMN_COUNT) * ROW_COUNT + row];
        }
    }
}

static void mix_columns(uint8_t *state) {
    for (size_t column = 0; column < COLUMN_COUNT; column++) {
        uint8_t *bytes = &state[column * ROW_COUNT];
        uint8_t all = (uint8_t)(bytes[0] ^ bytes[1] ^ bytes[2] ^ bytes[3]);
        uint8_t first = bytes[0];

        bytes[0] ^= all ^ multiply_by_two((uint8_t)(bytes[0] ^ bytes[1]));
        bytes[1] ^= all ^ multiply_by_two((uint8_t)(bytes[1] ^ bytes[2]));
        bytes[2] ^= all ^ multiply_by_two((uint8_t)(bytes[2] ^ bytes[3]));
        bytes[3] ^= all ^ multiply_by_two((uint8_t)(bytes[3] ^ first));
    }
}

void aes128_encrypt_block(const uint8_t key[AES128_KEY_SIZE],
                          const uint8_t input[AES128_BLOCK_SIZE],
                          uint8_t output[AES128_BLOCK_SIZE]) {
    uint8_t expanded_key[EXPANDED_KEY_SIZE];
    uint8_t state[STATE_SIZE];

    expand_key(key, expanded_key);
    memcpy(state, input, STATE_SIZE);

    add_round_key(state, expanded_key);
    for (size_t round = 1; round < ROUND_COUNT; round++) {
        substitute_bytes(state);
        shift_rows(state);
        mix_columns(state);
        add_round_key(state, &expanded_key[round * STATE_SIZE]);
    }

    substitute_bytes(state);
    shift_rows(state);
    add_round_key(state, &expanded_key[ROUND_COUNT * STATE_SIZE]);

    memcpy(output, state, STATE_SIZE);
}
